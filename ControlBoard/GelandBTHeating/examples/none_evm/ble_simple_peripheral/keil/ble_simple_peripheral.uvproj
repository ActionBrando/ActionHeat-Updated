# Keil uVision project ble_simple_peripheral.uvproj, settings and files
target ble_simple_peripheral (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ble_simple_peripheral +hex
  AfterMake: fromelf.exe  --text  -c -o Output/ble_simple_peripheral.txt  Objects/ble_simple_peripheral.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --preinclude app_config.h
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\driver\drv_common;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\platform\include\cmsis;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_simple_profile;..\code;..\..\..\..\components\modules\RTT
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x40000000 size 0x4000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: ..\..\..\..\components\toolchain\armcc\fr800x.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ble_simple_peripheral.c led_control.c temp_control.c voltage_detect.c key_control.c currency_detect.c bat_detect.c
  group driver
    ../../../../components/driver/: driver_pmu.c driver_adc.c driver_gpio.c driver_i2c.c driver_pwm.c driver_spi_master.c driver_flash.c driver_timer.c
  group platform
    ../../../../components/modules/platform/src/keil/: boot_vectors.s
  group lib
    ../../../../components/ble/library/: fr8000_stack.lib
  group modules
    ../../../../components/modules/common/src/: co_log.c
